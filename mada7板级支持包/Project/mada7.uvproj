# Keil uVision project mada7.uvproj, settings and files
target mada7 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: mada7 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libraries\CMSIS\startup;..\Libraries\CMSIS;..\Libraries\FWlib\src;..\Libraries\FWlib\inc;..\Libraries\FWlib;..\User
  group STARTUP
    ../Libraries/CMSIS/startup/: STARTUP.A51
  group CMSIS
    ../Libraries/CMSIS/: mada7.h mada7_config.h
  group FWLB
    ../Libraries/FWlib/src/: bsp_beef.c bsp_digital.c bsp_TLC5620.c bsp_systicks.c bsp_usart.c bsp_adc.c bsp_EEPROM.c bsp_watchdog.c bsp_key.c
  group USER
    ../User/: main.c mada7_it.c
  group DOC
    ../Doc/: 新建文本文档.TXT
